/* Astronomical events (see astro.h). The table is generated by
 * scripts/build_astro.py; a solar eclipse comes as the sun's and moon's
 * geocentric positions every 10 minutes, and is seen from the display's
 * place by shifting the moon for parallax (it is close enough for that to
 * be up to a degree) and comparing the two discs. */

#include <math.h>
#include <stddef.h>

#include "astro.h"
#include "astro_data.h"
#include "sun.h"

#define RAD          (M_PI / 180.0)
#define J2000_EPOCH  946728000.0 /* 2000-01-01 12:00 UTC */
#define EARTH_R_KM   6378.14
#define SUN_R_KM     696000.0
#define MOON_R_KM    1737.4
#define SOLAR_SPAN_S ((ASTRO_SOLAR_SAMPLES - 1) * ASTRO_SOLAR_STEP_S)
#define TRACKS       (sizeof(SOLAR_TRACKS) / sizeof(SOLAR_TRACKS[0]))
#define EVENTS       (sizeof(ASTRO_EVENTS) / sizeof(ASTRO_EVENTS[0]))

const char *astro_shower_name(int which)
{
    return which >= 0 && which < (int)(sizeof(SHOWER_NAME) / sizeof(SHOWER_NAME[0])) ? SHOWER_NAME[which] : "";
}

bool astro_known(int year)
{
    return year >= ASTRO_FIRST_YEAR && year <= ASTRO_LAST_YEAR;
}

int astro_last_year(void)
{
    return ASTRO_LAST_YEAR;
}

/* Right ascension, declination and distance as a vector. */
static void vec(double ra, double dec, double dist, double v[3])
{
    v[0] = dist * cos(dec) * cos(ra);
    v[1] = dist * cos(dec) * sin(ra);
    v[2] = dist * sin(dec);
}

static double len(const double v[3])
{
    return sqrt(v[0] * v[0] + v[1] * v[1] + v[2] * v[2]);
}

/* The angle between two vectors (atan2: exact for small angles too). */
static double angle(const double a[3], const double b[3])
{
    const double c[3] = { a[1] * b[2] - a[2] * b[1], a[2] * b[0] - a[0] * b[2], a[0] * b[1] - a[1] * b[0] };
    return atan2(len(c), a[0] * b[0] + a[1] * b[1] + a[2] * b[2]);
}

/* The share of a disc of radius rs covered by one of radius rm, d apart. */
static double overlap(double rs, double rm, double d)
{
    if (d >= rs + rm) {
        return 0;
    }
    if (d <= fabs(rm - rs)) {
        return rm >= rs ? 1 : (rm * rm) / (rs * rs);
    }
    const double a = rs * rs * acos((d * d + rs * rs - rm * rm) / (2 * d * rs));
    const double b = rm * rm * acos((d * d + rm * rm - rs * rs) / (2 * d * rm));
    const double c = 0.5 * sqrt((-d + rs + rm) * (d + rs - rm) * (d - rs + rm) * (d + rs + rm));
    return (a + b - c) / (M_PI * rs * rs);
}

/* Sample i's value k, and the next one's, with RA kept continuous. */
static double lerp(const astro_track_t *tr, int i, int k, double f)
{
    double a = tr->s[i][k], b = tr->s[i + 1][k];
    if (k == 0 || k == 3) {
        if (b - a > M_PI) {
            b -= 2 * M_PI;
        } else if (a - b > M_PI) {
            b += 2 * M_PI;
        }
    }
    return a + (b - a) * f;
}

double astro_solar_cover(int track, double lat, double lon, time_t *when, bool *annular)
{
    if (track < 0 || track >= (int)TRACKS) {
        return 0;
    }
    const astro_track_t *tr = &SOLAR_TRACKS[track];
    /* The observer, on the ellipsoid (Meeus ch. 11), at sea level. */
    const double phi = lat * RAD;
    const double u = atan(0.99664719 * tan(phi));
    const double rho_sin = 0.99664719 * sin(u), rho_cos = cos(u);
    const double up_z = sin(phi), up_r = cos(phi);
    double best = 0;
    for (int s = 0; s <= SOLAR_SPAN_S; s += 60) {
        const int i = s / ASTRO_SOLAR_STEP_S < ASTRO_SOLAR_SAMPLES - 1 ? s / ASTRO_SOLAR_STEP_S : ASTRO_SOLAR_SAMPLES - 2;
        const double f = (double)(s - i * ASTRO_SOLAR_STEP_S) / ASTRO_SOLAR_STEP_S;
        const double t = (double)tr->start + s;
        const double d = (t - J2000_EPOCH) / 86400.0;
        const double lst = fmod(280.46061837 + 360.98564736629 * d + lon, 360.0) * RAD;
        const double obs[3] = { EARTH_R_KM * rho_cos * cos(lst), EARTH_R_KM * rho_cos * sin(lst), EARTH_R_KM * rho_sin };
        double sun[3], moon[3];
        vec(lerp(tr, i, 0, f), lerp(tr, i, 1, f), lerp(tr, i, 2, f), sun);
        vec(lerp(tr, i, 3, f), lerp(tr, i, 4, f), lerp(tr, i, 5, f), moon);
        for (int k = 0; k < 3; k++) {
            sun[k] -= obs[k];
            moon[k] -= obs[k];
        }
        const double up[3] = { up_r * cos(lst), up_r * sin(lst), up_z };
        const double alt = M_PI / 2 - angle(sun, up);
        if (alt < -0.833 * RAD) {
            continue; /* set (allowing for refraction) */
        }
        const double rs = asin(SUN_R_KM / len(sun)), rm = asin(MOON_R_KM / len(moon));
        const double c = overlap(rs, rm, angle(sun, moon));
        if (c > best) {
            best = c;
            if (when) {
                *when = (time_t)t;
            }
            if (annular) {
                *annular = rm < rs && c >= (rm * rm) / (rs * rs) - 1e-9;
            }
        }
    }
    return best;
}

int astro_day(time_t day_start, time_t day_end, double lat, double lon, astro_item_t *out, int max)
{
    int n = 0;
    /* Everything that can land on the day lies within a day of it. */
    for (size_t i = 0; i < EVENTS && n < max; i++) {
        const astro_event_t *e = &ASTRO_EVENTS[i];
        if ((time_t)e->t < day_start - 86400 || (time_t)e->t >= day_end + 86400) {
            continue;
        }
        astro_item_t it = { .kind = (astro_kind_t)e->kind, .t = e->t, .value = e->arg };
        time_t on = e->t;
        if (e->kind == ASTRO_METEORS) {
            on -= 12 * 3600; /* the evening the night of the peak begins */
        } else if (e->kind == ASTRO_LUNAR_ECLIPSE) {
            /* The moon, opposite the sun, up at its greatest or an hour
             * either side (the partial phase lasts longer than that). */
            bool up = false;
            for (int m = -60; m <= 60; m += 60) {
                up |= sun_elevation_deg(lat, lon, (time_t)e->t + m * 60) < -1.5;
            }
            if (!up) {
                continue;
            }
        } else if (e->kind == ASTRO_SOLAR_ECLIPSE) {
            /* The same eclipse is asked about for the days around it. */
            static struct {
                int track;
                double lat, lon, cover;
                time_t when;
                bool annular;
            } last = { .track = -1 };
            if (last.track != e->arg || last.lat != lat || last.lon != lon) {
                last.cover = astro_solar_cover(e->arg, lat, lon, &last.when, &last.annular);
                last.track = e->arg;
                last.lat = lat;
                last.lon = lon;
            }
            if (last.cover < 0.005) {
                continue;
            }
            /* Per cent, 100 only when total. */
            const long pc = lround(last.cover * 100);
            it.value = last.cover >= 1 ? 100 : pc < 1 ? 1 : pc > 99 ? 99 : (int)pc;
            it.annular = last.annular;
            on = it.t = last.when;
        }
        if (on >= day_start && on < day_end) {
            /* In time order (a solar eclipse's own time may come before
             * the new moon's). */
            int k = n++;
            for (; k > 0 && out[k - 1].t > it.t; k--) {
                out[k] = out[k - 1];
            }
            out[k] = it;
        }
    }
    return n;
}
